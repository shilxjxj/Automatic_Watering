# Keil uVision project auto_water.uvproj, settings and files
target auto_water (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: auto_water +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\inc
  group User
    ./: STARTUP.A51 main.c
  group Src
    ../src/: LCD12864.c ESP8266.c
